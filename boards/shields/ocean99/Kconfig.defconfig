## boards/shields/ocean99/Kconfig.defconfig
```kconfig
if SHIELD_OCEAN99

config ZMK_KEYBOARD_NAME
    default "ocean99"

endif # SHIELD_OCEAN99
```
